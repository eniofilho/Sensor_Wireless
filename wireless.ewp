# IAR project wireless.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: CC430F5137 CC430F5137
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnkcc430F5137_custom.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: --ks_version
configuration Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  ICC430.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
configuration AccessPoint (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: ACCESS_POINT
configuration EndDevice (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: END_DEVICE
  group (top)
    ./: apOperationMachine.c button.c edOperationMachine.c flashParam.c led.c main.c radio.c scrambler.c serial.c uart.c watchdog.c
